Commit message: added mimic joint

File: urdf/myrobot.urdf (robot description, URDF)
Before this commit: robot robot, 8 links, 7 joints
Joints:
- joint gripper_base_to_finger_right: mimic (none) -> joint=gripper_base_to_finger_left multiplier=-1
